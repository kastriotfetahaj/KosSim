options:
  parameters:
    author: PistonMiner
    generate_options: no_gui
    id: heavensent_client
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: BANDWIDTH_HZ
  id: variable
  parameters:
    value: '1800'
  states: {}
- name: CONTENT_BYTE_COUNT
  id: variable
  parameters:
    value: '64'
  states: {}
- name: FRAME_BYTE_COUNT
  id: variable
  parameters:
    value: CONTENT_BYTE_COUNT + 4
  states: {}
- name: FRAME_SYMBOL_COUNT
  id: variable
  parameters:
    value: FRAME_BYTE_COUNT * SYM_PER_BYTE
  states: {}
- name: FRAME_SYNC_SYMBOLS
  id: variable
  parameters:
    value: '[0x0, 0x0, 0x0, 0xf, 0xf, 0x0, 0xf, 0x0, 0xf, 0xf, 0x0, 0x0, 0xf, 0xf, 0xf, 0xf, 0xf, 0xf, 0xf, 0xf, 0xf, 0xf, 0x0, 0x0, 0x0, 0x0, 0x0, 0xf, 0xf, 0xf, 0x0, 0xf]'
  states: {}
- name: SYM_BASE
  id: variable
  parameters:
    value: '16'
  states: {}
- name: SYM_PER_BYTE
  id: variable
  parameters:
    value: '2'
  states: {}
- name: access_code
  id: variable
  parameters:
    value: '"".join(map(str, sync_bits))'
  states: {}
- name: block_num_samples
  id: variable
  parameters:
    value: samp_rate//16
  states: {}
- name: block_size_bytes
  id: variable
  parameters:
    value: block_num_samples * samp_size_bytes
  states: {}
- name: block_time
  id: variable
  parameters:
    comment: for reference against idle time
    value: block_num_samples/samp_rate
  states: {}
- name: frame_preamble
  id: variable
  parameters:
    value: FRAME_SYNC_SYMBOLS
  states: {}
- name: frame_size_bits
  id: variable
  parameters:
    value: FRAME_SYMBOL_COUNT * sym_base_bits
  states: {}
- name: frame_sync_bytes
  id: variable
  parameters:
    value: util.pack_symbols(FRAME_SYNC_SYMBOLS)
  states: {}
- name: fsk16_constellation
  id: variable_constellation
  parameters:
    const_points: list(np.linspace(-1, 1, SYM_BASE))
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: list(range(SYM_BASE))
    type: calcdist
  states: {}
- name: hz_per_lsb
  id: variable
  parameters:
    value: BANDWIDTH_HZ/(SYM_BASE - 1)
  states: {}
- name: margin
  id: variable
  parameters:
    comment: |-
      how much more samples we send percentage wise.
      the correlator block has a delay in outputting its samples,
      which means that depending on the configuration
      we need to put in some extra samples to flush it out for
      a clean block.
    value: '1.5'
  states: {}
- name: num_frame_samples
  id: variable
  parameters:
    value: int(num_frame_symbols*sps)
  states: {}
- name: num_frame_symbols
  id: variable
  parameters:
    value: len(frame_preamble)+FRAME_SYMBOL_COUNT
  states: {}
- name: post_frame_idle_samples
  id: variable
  parameters:
    value: ((int(num_frame_samples*margin) + block_num_samples - 1) // block_num_samples) * block_num_samples - num_frame_samples
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: samp_size_bytes
  id: variable
  parameters:
    value: '8'
  states: {}
- name: service_port
  id: variable
  parameters:
    value: '"9501"'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/sym_rate
  states: {}
- name: sym_base_bits
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: sync_bits
  id: variable
  parameters:
    value: np.unpackbits(np.array(frame_sync_bytes, dtype="uint8")).astype('int')
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_1
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi)
  states: {}
- name: analog_quadrature_demod_cf_1_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi)
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    comment: center constellation
    const: '-BANDWIDTH_HZ / 2'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_1
  id: blocks_add_const_vxx
  parameters:
    comment: center constellation
    const: BANDWIDTH_HZ / 2
    type: float
  states: {state: disabled}
- name: blocks_add_const_vxx_0_2
  id: blocks_add_const_vxx
  parameters:
    comment: normalize into [0; 15]
    const: (SYM_BASE - 1) / 2
    type: float
  states: {}
- name: blocks_add_const_vxx_0_2_0
  id: blocks_add_const_vxx
  parameters:
    comment: normalize into [0; 15]
    const: (SYM_BASE - 1) / 2
    type: float
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    comment: downlink doppler
    freq: doppler_hz
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_0_0
  id: blocks_freqshift_cc
  parameters:
    comment: uplink doppler
    freq: doppler_hz
    sample_rate: samp_rate
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {state: disabled}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {state: disabled}
- name: blocks_message_debug_3_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: normalize into [-1; 1] for sync
    const: 1/(hz_per_lsb * (SYM_BASE - 1)/2)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: convert to Hz
    const: hz_per_lsb
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: normalize
    const: 1/hz_per_lsb
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    comment: normalize into [-7.5; 7.5]
    const: (SYM_BASE - 1) / 2
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_2_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: normalize into [-7.5; 7.5]
    const: (SYM_BASE - 1) / 2
    type: float
  states: {state: disabled}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: sym_base_bits
    l: '1'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(sps)
    type: byte
  states: {}
- name: blocks_stream_mux_1
  id: blocks_stream_mux
  parameters:
    lengths: (num_frame_samples, post_frame_idle_samples)
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: '"syncword"'
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_1
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: 2*np.pi
  states: {}
- name: client_port
  id: parameter
  parameters:
    label: client-port
    type: str
    value: '9502'
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: '0'
    sps: sps-1
    symbols: util.modulate_symbols(FRAME_SYNC_SYMBOLS, sps, hz_per_lsb, SYM_BASE, samp_rate)
    threshold: '0.9'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: access_code[-64:]
    tagname: syncword
    threshold: '0'
    type: byte
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: fsk16_constellation
    damping: '1.0'
    loop_bw: '0'
    max_dev: '0.001'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: ff
  states: {}
- name: doppler_hz
  id: parameter
  parameters:
    label: doppler-hz
    type: eng_float
    value: '0.0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      # SPDX-License-Identifier: GPL-3.0

      import numpy as np
      from gnuradio import gr
      import pmt


      class hs_startup_sync(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='HeavenSent Startup Sync',
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.msg_handler)

              self.message_port_register_out(pmt.intern("out"))
              self.message_port_register_out(pmt.intern("loopback"))

              self.synchronized = False

          def msg_handler(self, msg):
              if not self.synchronized:
                  # Not synchronized yet, receiving sync requests instead of packets
                  if not pmt.is_pdu(msg):
                      gr.log.warn(f"HS Sync: input message {repr(msg)} is not a PDU, dropping")
                      return

                  data = pmt.to_python(pmt.cdr(msg))

                  # We assume that the connection could go "live" at any byte boundary.
                  # Therefore the synchronization protocol must only use single byte commands.

                  # Protect against multiple packets being merged because this is TCP
                  # For this to work there has to be a guarantee that the transition from
                  # unsynchronized to synchronized does not happen within a PDU.
                  # We can guarantee this because we will enter synchronized state when
                  # we send our own "sync ack" PDU which the client must wait for.
                  if len(data) > 1:
                      gr.log.warn(f"HS Sync: received {len(data)} bytes at a time while waiting for sync (data={repr(data)})")
                  for request_code in data:
                      if self.synchronized:
                          gr.log.warn(f"HS Sync: received sync requests while already synchronized, this data will end up dropped!")
                          break

                      self.sync_action(request_code)
              else:
                  # Pass message through
                  self.message_port_pub(pmt.intern("out"), msg)

          def sync_action(self, request_code):
              if request_code == ord("W"):
                  # Client is waiting for sync, let it know we are ready
                  response_code = ord("R")
              elif request_code == ord("S"):
                  # Client wants to start now, acknowledge
                  response_code = ord("A")
                  self.synchronized = True
              else:
                  gr.log.warn(f"HS Sync: received bad sync request {request_code}, dropping")
                  return

              # Respond
              response_vec = pmt.to_pmt(np.array([response_code], dtype=np.uint8))
              response_msg = pmt.cons(pmt.PMT_NIL, response_vec)
              self.message_port_pub(pmt.intern("loopback"), response_msg)
    comment: |-
      This abomination is necessary to work around an apparent GNU Radio
      issue where, if connecting to this Socket PDU from externally and sending
      data, if you connect too early, the data will simply be dropped.
      Therefore we have to perform this elaborate song and dance routine of
      talking between Python client and flowgraph to make sure GNU Radio is
      actually, properly ready, before we start sending actual packets.

      TL;DR don't worry about it.
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: np.array(np.ones(int(sps-2)))/int(sps-2)
    type: fff
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: service_host
    mtu: block_size_bytes
    port: service_port
    tcp_no_delay: 'True'
    type: TCP_CLIENT
  states: {}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    mtu: CONTENT_BYTE_COUNT
    port: client_port
    tcp_no_delay: 'True'
    type: TCP_SERVER
  states: {}
- name: pdu_pdu_lambda_0
  id: pdu_pdu_lambda
  parameters:
    comment: parse c64
    fn: 'lambda a: np.frombuffer(a, dtype=np.complex64)'
    metadict: Uniform Vector
  states: {}
- name: pdu_pdu_lambda_1
  id: pdu_pdu_lambda
  parameters:
    comment: unpack symbols
    fn: 'lambda a: np.array(util.unpack_symbols(a),dtype="uint8")'
    metadict: Uniform Vector
  states: {}
- name: pdu_pdu_lambda_1_0
  id: pdu_pdu_lambda
  parameters:
    comment: attach preamble
    fn: 'lambda a: np.concatenate((np.array(frame_preamble,dtype="uint8"),a))'
    metadict: Uniform Vector
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: complex
  states: {}
- name: pdu_pdu_to_stream_x_0_0
  id: pdu_pdu_to_stream_x
  parameters:
    comment: Ensure the PDUs coming out of here are properly sized
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: pdu_pdu_to_stream_x_1
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_take_skip_to_pdu_0
  id: pdu_take_skip_to_pdu
  parameters:
    skip: '0'
    take: block_num_samples
    type: complex
  states: {}
- name: pdu_take_skip_to_pdu_0_0
  id: pdu_take_skip_to_pdu
  parameters:
    skip: '0'
    take: CONTENT_BYTE_COUNT
    type: byte
  states: {}
- name: pdu_take_skip_to_pdu_1
  id: pdu_take_skip_to_pdu
  parameters:
    skip: '0'
    take: block_size_bytes
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    name: '"rx"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    name: '"tx"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"rx iq"'
    size: 10*samp_rate
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"tx iq"'
    size: block_num_samples
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"rx symbol sync in"'
    size: int(samp_rate*block_time*0.5)
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"rx soft symbols"'
    size: int(sym_rate*block_time*0.5)
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_1
  id: qtgui_time_sink_x
  parameters:
    name: '"tx fm"'
    size: samp_rate
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_2
  id: qtgui_time_sink_x
  parameters:
    name: '"rx correlation"'
    size: int(samp_rate*block_time*0.5)
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_2_0
  id: qtgui_time_sink_x
  parameters:
    name: '"rx raw"'
    size: int(samp_rate*block_time*0.5)
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_2_1
  id: qtgui_time_sink_x
  parameters:
    name: '"rx correlation mag"'
    size: int(samp_rate*0.35)
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_3_0
  id: qtgui_time_sink_x
  parameters:
    name: '"rx sync error"'
    nconnections: '3'
    size: int(block_time*sym_rate*0.5)
    srate: sym_rate
    type: float
  states: {state: disabled}
- name: satellites_fixedlen_to_pdu_0
  id: satellites_fixedlen_to_pdu
  parameters:
    pack: 'True'
    packet_len: frame_size_bits
    syncword_tag: syncword
    type: byte
  states: {}
- name: service_host
  id: parameter
  parameters:
    label: service-host
    type: str
    value: localhost
  states: {}
- name: util
  id: epy_module
  parameters:
    source_code: "# SPDX-License-Identifier: GPL-3.0\r\n\r\ndef unpack_symbols(data):\r\n\tsyms = []\r\n\tfor b in data:\r\n\t\tsyms.append((b >> 4) & 0xf)\r\n\t\tsyms.append((b >> 0) & 0xf)\r\n\treturn syms\r\n\r\ndef pack_symbols(syms):\r\n\tassert len(syms) % 2 == 0\r\n\tbyte_count = len(syms) // 2\r\n\tdata = bytearray(byte_count)\r\n\tfor i in range(byte_count):\r\n\t\thi_sym = syms[2*i+0]\r\n\t\tlo_sym = syms[2*i+1]\r\n\t\tdata[i] = (hi_sym << 4) | lo_sym\r\n\treturn data\r\n\r\ndef modulate_symbols(syms, sps, hz_per_lsb, SYM_BASE, samp_rate):\r\n\timport numpy as np\r\n\tsym_freqs = (np.array(syms) - (SYM_BASE - 1) / 2) * hz_per_lsb\r\n\tsample_freqs = np.repeat(sym_freqs, int(sps))\r\n\tsample_omega = 2 * np.pi / samp_rate * sample_freqs\r\n\tsample_phase = np.cumsum(sample_omega)\r\n\tiq_samples = np.exp(1j * sample_phase)\r\n\treturn iq_samples"
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rx packets
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: rx iq
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: tx iq
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: tx packets
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rx iq
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: tx iq
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: rx packets
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: tx packets
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_stream_mux_1, '1']
- [analog_quadrature_demod_cf_1, '0', blocks_multiply_const_vxx_0, '0']
- [analog_quadrature_demod_cf_1_0, '0', blocks_add_const_vxx_0_1, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_vco_c_0, '0']
- [blocks_add_const_vxx_0_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_add_const_vxx_0_2, '0', blocks_float_to_uchar_0, '0']
- [blocks_add_const_vxx_0_2, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_add_const_vxx_0_2_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0_1_2_1, '0']
- [blocks_float_to_uchar_0, '0', blocks_repack_bits_bb_1, '0']
- [blocks_freqshift_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_freqshift_cc_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_freqshift_cc_0, '0', virtual_sink_0_0, '0']
- [blocks_freqshift_cc_0_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', fir_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', qtgui_time_sink_x_0_1_1, '0']
- [blocks_multiply_const_vxx_0_2, '0', blocks_add_const_vxx_0_2, '0']
- [blocks_multiply_const_vxx_0_2_0, '0', blocks_add_const_vxx_0_2_0, '0']
- [blocks_repack_bits_bb_1, '0', digital_correlate_access_code_tag_xx_0, '0']
- [blocks_repeat_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_stream_mux_1, '0', analog_quadrature_demod_cf_1_0, '0']
- [blocks_stream_mux_1, '0', virtual_sink_0_0_0, '0']
- [blocks_tag_gate_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_throttle2_0, '0', pdu_take_skip_to_pdu_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_vco_c_0, '0', blocks_stream_mux_1, '0']
- [digital_corr_est_cc_0, '0', analog_quadrature_demod_cf_1, '0']
- [digital_corr_est_cc_0, '0', blocks_tag_debug_1, '0']
- [digital_corr_est_cc_0, '0', qtgui_time_sink_x_0_1_2_0, '0']
- [digital_corr_est_cc_0, '1', blocks_complex_to_mag_0, '0']
- [digital_corr_est_cc_0, '1', qtgui_time_sink_x_0_1_2, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_tag_debug_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', satellites_fixedlen_to_pdu_0, '0']
- [digital_crc_append_0, out, pdu_pdu_lambda_1, pdu]
- [digital_crc_check_0, fail, blocks_message_debug_3_0, log]
- [digital_crc_check_0, ok, virtual_sink_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_multiply_const_vxx_0_2, '0']
- [digital_symbol_sync_xx_0, '1', qtgui_time_sink_x_0_1_3_0, '0']
- [digital_symbol_sync_xx_0, '2', qtgui_time_sink_x_0_1_3_0, '1']
- [digital_symbol_sync_xx_0, '3', qtgui_time_sink_x_0_1_3_0, '2']
- [epy_block_0, loopback, network_socket_pdu_0_0, pdus]
- [epy_block_0, out, pdu_pdu_to_stream_x_1, pdus]
- [fir_filter_xxx_0, '0', blocks_multiply_const_vxx_0_2_0, '0']
- [fir_filter_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [network_socket_pdu_0, pdus, pdu_pdu_to_stream_x_0_0, pdus]
- [network_socket_pdu_0_0, pdus, epy_block_0, in]
- [pdu_pdu_lambda_0, pdu, blocks_message_debug_0_0, log]
- [pdu_pdu_lambda_0, pdu, pdu_pdu_to_stream_x_0, pdus]
- [pdu_pdu_lambda_1, pdu, pdu_pdu_lambda_1_0, pdu]
- [pdu_pdu_lambda_1_0, pdu, pdu_pdu_to_tagged_stream_1, pdus]
- [pdu_pdu_to_stream_x_0, '0', blocks_tag_gate_0, '0']
- [pdu_pdu_to_stream_x_0_0, '0', pdu_take_skip_to_pdu_1, '0']
- [pdu_pdu_to_stream_x_1, '0', pdu_take_skip_to_pdu_0_0, '0']
- [pdu_pdu_to_tagged_stream_1, '0', blocks_repeat_0, '0']
- [pdu_take_skip_to_pdu_0, pdus, blocks_message_debug_1, log]
- [pdu_take_skip_to_pdu_0, pdus, network_socket_pdu_0, pdus]
- [pdu_take_skip_to_pdu_0_0, pdus, blocks_message_debug_0, log]
- [pdu_take_skip_to_pdu_0_0, pdus, virtual_sink_1, '0']
- [pdu_take_skip_to_pdu_1, pdus, pdu_pdu_lambda_0, pdu]
- [satellites_fixedlen_to_pdu_0, pdus, digital_crc_check_0, in]
- [virtual_source_0, '0', digital_corr_est_cc_0, '0']
- [virtual_source_0_0, '0', blocks_freqshift_cc_0_0, '0']
- [virtual_source_1, '0', network_socket_pdu_0_0, pdus]
- [virtual_source_1_0, '0', digital_crc_append_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
