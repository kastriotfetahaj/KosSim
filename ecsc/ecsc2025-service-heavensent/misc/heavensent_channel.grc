options:
  parameters:
    generate_options: qt_gui
    id: heavensent_channel
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BANDWIDTH_HZ
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: SYM_BASE
  id: variable
  parameters:
    value: '16'
  states: {}
- name: block_num_samples
  id: variable
  parameters:
    value: samp_rate//10
  states: {}
- name: block_size_bytes
  id: variable
  parameters:
    value: block_num_samples * samp_size_bytes
  states: {}
- name: channel_max_doppler
  id: variable
  parameters:
    value: 10e3
  states: {state: disabled}
- name: channel_max_doppler
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: channel_port
  id: variable
  parameters:
    value: '"9500"'
  states: {}
- name: host
  id: variable
  parameters:
    value: '"localhost"'
  states: {}
- name: hz_per_lsb
  id: variable
  parameters:
    value: BANDWIDTH_HZ/(SYM_BASE - 1)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: samp_size_bytes
  id: variable
  parameters:
    value: '8'
  states: {}
- name: service_port
  id: variable
  parameters:
    value: '"9501"'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/sym_rate
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: analog_quadrature_demod_cf_1_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi)
  states: {}
- name: analog_quadrature_demod_cf_1_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: channel_max_doppler
    freq: 1/(15*60)
    offset: '0'
    phase: np.pi/2
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_const_vxx_0_1
  id: blocks_add_const_vxx
  parameters:
    comment: center constellation
    const: BANDWIDTH_HZ / 2
    type: float
  states: {}
- name: blocks_add_const_vxx_0_1_0
  id: blocks_add_const_vxx
  parameters:
    comment: center constellation
    const: BANDWIDTH_HZ / 2
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: normalize
    const: 1/hz_per_lsb
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: normalize
    const: 1/hz_per_lsb
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_tag_gate_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: 2*np.pi
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.1'
    seed: '0'
    taps: '1.0'
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.1'
    seed: '0'
    taps: '1.0'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: np.array([1/int(sps)]*int(sps))
    type: fff
  states: {state: disabled}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: host
    mtu: block_size_bytes
    port: service_port
    tcp_no_delay: 'True'
    type: TCP_CLIENT
  states: {}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    host: host
    mtu: block_size_bytes
    port: channel_port
    tcp_no_delay: 'True'
    type: TCP_SERVER
  states: {}
- name: pdu_pdu_lambda_0
  id: pdu_pdu_lambda
  parameters:
    fn: 'lambda a: np.frombuffer(a, dtype=np.complex64)'
    metadict: Uniform Vector
  states: {}
- name: pdu_pdu_lambda_0_0
  id: pdu_pdu_lambda
  parameters:
    fn: 'lambda a: np.frombuffer(a, dtype=np.complex64)'
    metadict: Uniform Vector
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: complex
  states: {}
- name: pdu_pdu_to_stream_x_0_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: complex
  states: {}
- name: pdu_take_skip_to_pdu_0
  id: pdu_take_skip_to_pdu
  parameters:
    skip: '0'
    take: block_num_samples
    type: complex
  states: {}
- name: pdu_take_skip_to_pdu_0_0
  id: pdu_take_skip_to_pdu
  parameters:
    skip: '0'
    take: block_num_samples
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: 0,0,1,1
    name: '"uplink @ G/S"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: 0,1,1,1
    name: '"downlink @ S/C"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: 1,1,1,1
    name: '"downlink @ G/S"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: 1,0,1,1
    name: '"uplink @ S/C"'
    type: complex
    wintype: window.WIN_FLATTOP
  states: {}
- name: qtgui_time_sink_x_0_1_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0,1,1
    name: '"uplink @ S/C FM"'
    size: samp_rate//4
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,0,1,1
    name: '"uplink @ S/C time"'
    size: samp_rate//3
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1_1_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,1,1,1
    name: '"downlink @ G/S time"'
    size: samp_rate//3
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1_1_1
  id: qtgui_time_sink_x
  parameters:
    name: '"tx fm filtered"'
    size: samp_rate//3
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_1_2
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,1,1,1
    name: '"downlink @ G/S FM"'
    size: samp_rate//4
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: uplink_in_iq
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: downlink_in_iq
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: uplink_out_iq
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: downlink_out_iq
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: downlink_out_iq
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: uplink_out_iq
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: uplink_in_iq
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: downlink_in_iq
  states: {}

connections:
- [analog_quadrature_demod_cf_1_0, '0', blocks_add_const_vxx_0_1, '0']
- [analog_quadrature_demod_cf_1_0_0, '0', blocks_add_const_vxx_0_1_0, '0']
- [analog_sig_source_x_0, '0', blocks_vco_c_0, '0']
- [blocks_add_const_vxx_0_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_add_const_vxx_0_1_0, '0', blocks_multiply_const_vxx_0_1_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', fir_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', qtgui_time_sink_x_0_1_1, '0']
- [blocks_multiply_const_vxx_0_1_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_1_0, '0', qtgui_time_sink_x_0_1_1_2, '0']
- [blocks_multiply_xx_0, '0', channels_channel_model_0, '0']
- [blocks_multiply_xx_0_0, '0', channels_channel_model_0_0, '0']
- [blocks_tag_gate_0, '0', virtual_sink_0, '0']
- [blocks_tag_gate_0_0, '0', virtual_sink_0_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_0, '1']
- [blocks_vco_c_0, '0', blocks_multiply_xx_0_0, '1']
- [channels_channel_model_0, '0', analog_quadrature_demod_cf_1_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0_1, '0']
- [channels_channel_model_0, '0', qtgui_time_sink_x_0_1_1_0, '0']
- [channels_channel_model_0, '0', virtual_sink_0_1, '0']
- [channels_channel_model_0_0, '0', analog_quadrature_demod_cf_1_0_0, '0']
- [channels_channel_model_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [channels_channel_model_0_0, '0', qtgui_time_sink_x_0_1_1_0_0, '0']
- [channels_channel_model_0_0, '0', virtual_sink_0_1_0, '0']
- [fir_filter_xxx_0, '0', qtgui_time_sink_x_0_1_1_1, '0']
- [network_socket_pdu_0, pdus, pdu_pdu_lambda_0_0, pdu]
- [network_socket_pdu_0_0, pdus, pdu_pdu_lambda_0, pdu]
- [pdu_pdu_lambda_0, pdu, pdu_pdu_to_stream_x_0, pdus]
- [pdu_pdu_lambda_0_0, pdu, pdu_pdu_to_stream_x_0_0, pdus]
- [pdu_pdu_to_stream_x_0, '0', blocks_tag_gate_0, '0']
- [pdu_pdu_to_stream_x_0_0, '0', blocks_tag_gate_0_0, '0']
- [pdu_take_skip_to_pdu_0, pdus, network_socket_pdu_0_0, pdus]
- [pdu_take_skip_to_pdu_0_0, pdus, network_socket_pdu_0, pdus]
- [virtual_source_0, '0', pdu_take_skip_to_pdu_0, '0']
- [virtual_source_0_0, '0', pdu_take_skip_to_pdu_0_0, '0']
- [virtual_source_0_0_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_0_0_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0_0_0_0, '0', blocks_multiply_xx_0_0, '0']
- [virtual_source_0_0_0_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
